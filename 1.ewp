# IAR project 1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: G:\TAM\K\ARM\STM8\PROJECT\Digital clock lcd\Sample\TEST_LCD\Libraries\STM8L15x_StdPeriph_Driver\inc; G:\TAM\K\ARM\STM8\PROJECT\Digital clock lcd\Sample\TEST_LCD
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
  group Driver
    Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_lcd.c stm8l15x_rtc.c stm8l15x_tim4.c
